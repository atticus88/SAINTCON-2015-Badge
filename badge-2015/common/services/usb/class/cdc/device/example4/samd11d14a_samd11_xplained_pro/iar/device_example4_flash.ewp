# IAR project device_example4_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; __SAMD11D14AM__; BOARD=SAMD11_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/interrupt; ../../..; ../..; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/boards/samd11_xplained_pro; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../../sleepmgr; ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../sam0/utils/cmsis/samd11/source; ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r; ../../../..; ../../../../../../../../../sam0/drivers/system/clock/clock_samd10_d11; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../../../udc; ../../../../../..; ../../../../../../../../utils; ../../../../../../../../../sam0/utils/cmsis/samd11/include; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/utils/header_files; ..; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example4_flash.bin
  ILINK.IlinkOutputFile: device_example4_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x4CC
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/example4
    ../../: main.c conf_usb.h ui.h main.h
  group common/services/usb/class/cdc/device/example4/samd11d14a_samd11_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/cdc/device/example4/samd11d14a_samd11_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../../../../sam0/utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../../../../sam0/utils/cmsis/samd11/include/: samd11d14as.h samd11d14am.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd11/include/instance/: pac1.h dmac.h sysctrl.h rtc.h eic.h tc1.h ac.h sbmatrix.h pm.h wdt.h mtb.h tc2.h gclk.h dsu.h sercom0.h sercom1.h usb.h evsys.h pac0.h nvmctrl.h pac2.h dac.h tcc0.h port.h adc.h sercom2.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd11/include/pio/: samd11d14as.h samd11d14am.h samd11c14a.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd11/include/component/: adc.h rtc.h nvmctrl.h dac.h wdt.h pm.h gclk.h pac.h port.h eic.h mtb.h tc.h evsys.h hmatrixb.h dmac.h sysctrl.h dsu.h tcc.h ac.h usb.h sercom.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../../../../sam0/boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
