# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMR21_XPLAINED_PRO; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../../sam0/utils/cmsis/samr21/include; ../../../..; ../../../../../../../../../boards; ../..; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c udi_hid_generic.h udi_hid_generic_conf.h
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c conf_usb.h main.h ui.h
  group common/services/usb/class/hid/device/generic/example/samr21g18a_samr21_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/device/generic/example/samr21g18a_samr21_xplained_pro/iar
    ./: asf.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/: samr21e18a.h samr21g18a.h samr21g16a.h samr21e16a.h samr21g17a.h samr21e17a.h samr21.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/instance/: sercom3.h mtb.h sercom1.h eic.h pac1.h tc5.h tc4.h sercom5.h port.h usb.h ac.h sercom2.h wdt.h sercom0.h tc3.h pm.h sbmatrix.h pac2.h rfctrl.h sysctrl.h tcc2.h tcc1.h tcc0.h gclk.h adc.h sercom4.h nvmctrl.h evsys.h dsu.h pac0.h rtc.h dmac.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/component/: dsu.h sercom.h dmac.h tc.h mtb.h eic.h port.h wdt.h tcc.h adc.h usb.h sysctrl.h evsys.h pac.h pm.h rfctrl.h nvmctrl.h gclk.h ac.h hmatrixb.h rtc.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21g17a.h samr21g18a.h samr21e16a.h samr21e17a.h samr21g16a.h samr21e18a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h mrecursion.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
